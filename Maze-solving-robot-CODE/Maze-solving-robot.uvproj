# Keil uVision project Maze-solving-robot.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: Maze-solving-robot +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c UART.c UART.h delay.c delay.h servo.c servo.h HCSR04.c HCSR04.h BYJ48.c BYJ48.h MazeSolving.c MazeSolving.h
